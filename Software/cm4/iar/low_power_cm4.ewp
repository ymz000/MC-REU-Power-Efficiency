# IAR project low_power_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_LPC54102J512BD64_cm4; CPU_LPC54102J512BD64
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC54102; ../../../..; ..; ../..; ../../sensors; ../../../../../../devices/LPC54102/drivers; ../../../../../../devices/LPC54102/utilities/io; ../../../../../../devices/LPC54102/utilities/str; ../../../../../../devices/LPC54102/utilities/log; ../../../../../../devices/LPC54102/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: low_power_cm4.out
  ILINK.IlinkKeepSymbols: _low_power_cm0plus_image
  ILINK.IlinkIcfFile: LPC54102J512_cm4.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/LPC54102/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_LPC54102J512BD64_cm4; CPU_LPC54102J512BD64
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../: pin_mux.c pin_mux.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/LPC54102/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_mailbox.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h fsl_utick.c
  group sensors
    ../../sensors/: bma2x2.h bmi160.h bmm050.h bmp280.h
  group source
    ../: low_power.h low_power_core0.c static_queue.h
  group startup
    ../../../../../../devices/LPC54102/iar/: startup_LPC54102_cm4.s
    ../../../../../../devices/LPC54102/: system_LPC54102_cm4.c system_LPC54102_cm4.h
  group utilities
    ../../../../../../devices/LPC54102/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC54102/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/LPC54102/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/LPC54102/utilities/str/: fsl_str.c fsl_str.h
